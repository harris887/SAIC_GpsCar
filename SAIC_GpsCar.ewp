# IAR project SAIC_GpsCar.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxC ST STM32F10xxC
  ICCARM.CCIncludePath2: library\inc\; ; User\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: SAIC_GpsCar.bin
  ILINK.IlinkOutputFile: SAIC_GpsCar.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group core
    core/: cortexm3_macro.s stm32f10x_vector.c
  group library/inc
    library/inc/: cortexm3_macro.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h
  group library/src
    library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    User/: Adc.c Adc.h ADS8431.c ADS8431.h BMS.c BMS.h Button.c Button.h Buzzer.c Buzzer.h Delay.c Delay.h DIDO.c DIDO.h init.c init.h LedDisp.c LedDisp.h LightSensor.c LightSensor.h ModBus.c ModBus.h ModBus_UserInterface.c ModBus_UserInterface.h moto.c moto.h moto_monitor.c moto_monitor.h PGV.c PGV.h Pid.c Pid.h Program.c Program.h Protocol.c Protocol.h Remote.c Remote.h Rfid.c Rfid.h SpeedLine.c SpeedLine.h Usart.c Usart.h user_inc.h user_lib.c user_lib.h WK2124.c WK2124.h
